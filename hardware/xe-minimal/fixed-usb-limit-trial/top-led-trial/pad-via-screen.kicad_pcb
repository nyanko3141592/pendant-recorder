# Repository nyanko3141592/pendant-recorder

## KiCad design hardware/xe-minimal/fixed-usb-limit-trial/top-led-trial/pad-via-screen.kicad_pcb

Schematic: pendant-xe-minimal.kicad_sch, Pendant Recorder - Omi-derived electrical design

Parts:
C1, C2, C3, C6, C9, C22, C26: 100n; C_0402_1005Metric
C4: 10u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C7, C16, C25: 1u; C_0402_1005Metric
C13: 2.2u 10V; C_0402_1005Metric
C14: 2.2u; C_0402_1005Metric
C15: 10u 10V effective >=1u; C_0603_1608Metric
C27: 4.7u effective TBD; C_0603_1608Metric
C28: 10n; C_0402_1005Metric
C29, C32, C33: 100n 10V; C_0402_1005Metric
C30: 50p 50V C0G; C_0402_1005Metric
C31: 1u 10V; C_0402_1005Metric
D6: amber LED 0402 TBD; LED_0402_1005Metric
J1: USB4105-GF-A (candidate); USB_C_GCT_USB4105_GroundLand112
J2: Molex781710003 / DTP401525-XE; Molex_Pico-EZmate_78171-0003_1x03-1MP_P1.20mm_Vertical
J3: Factory SWD pogo candidate; SWD_Pogo_5Pad_P1.27mm
Q3, Q4: DMN63D8L-7; SOT-23
Q6, Q7: 2N7002; SOT-23
R1: 0R; R_0402_1005Metric
R2: 10k; R_0402_1005Metric
R3, R13, R15, R22: 100k; R_0402_1005Metric
R6, R7: 5.1k 1%; R_0402_1005Metric
R10: 6.8k 1%; R_0402_1005Metric
R11, R39: 20k 1%; R_0402_1005Metric
R12, R36, R37, R38, R40, R49, R50: 100k 1%; R_0402_1005Metric
R14: 1M; R_0402_1005Metric
R21, R23: 22R tentative; R_0402_1005Metric
R24, R25, R28: 47k; R_0402_1005Metric
R32: 6.8k tentative; R_0402_1005Metric
R33, R34: 1M 1%; R_0402_1005Metric
R35, R47, R48: 10k 1%; R_0402_1005Metric
R41: 7.5k 1%; R_0402_1005Metric
R42: 130k 1%; R_0402_1005Metric
R43: 4.7k 1%; R_0402_1005Metric
R44: 19.1k 0.1%; R_0402_1005Metric
TH1: NCP18XH103F03RB 10k 1% B3380 candidate; R_0603_1608Metric
TP1, TP2, TP3, TP5, TP6: TestPoint; TestPoint_Pad_D1.0mm
U1: STM32U535CEU6; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U2: USBLC6-2P6; SOT-666
U3: BQ25185DLHR; Texas_DLH0010A_WSON-10-1EP_2.2x2mm_P0.4mm_EP0.9x1.5mm
U4: TPS7A0233PDBVR; SOT-23-5
U8: IM69D130V01XTSA1; IM69D130_JLC_SMD_trial
U10: TPS22916CYFPR; TPS22916_YFP4
U11: CSNP32GCR01-BOW candidate; CSNP32GCR01_LGA8
U12: TLV7042DDFR; SOT-23-8
U13: TPS22950YBHR; TPS22950_YBH0006-C02_SMD_TI_4226594A
U14: SN74HCS74DYYR; Texas_DYY0014A
U15: TLV803EB29DBZR; SOT-23

Connections:
/BAT: C14.1, J2.1 (PACK_PLUS), R33.1, TP1.1, U3.2 (BAT)
/BAT_ADC: C28.1, R33.2, R34.1, U1.11 (PA1)
/BAT_TS: R37.2, TH1.1 (SENSE), U12.2 (INA-), U12.5 (INB+)
/BOOT0: R3.1, U1.44 (PH3)
/CC1: J1.A5 (CC1), R6.1
/CC2: J1.B5 (CC2), R7.1
/CHARGER_TS: R35.1, U3.6 (TS_MR)
/CHG_ALLOW: R43.1, U1.20 (PB2)
/CHG_GUARD_GATE: Q4.1 (G), R36.1, R43.2, U12.1 (OUTA), U12.7 (OUTB)
/CHG_INHIBIT_GATE: Q4.3 (D), R12.2, U3.4 (CE_N)
/CHG_N: R11.2, U1.27 (PB14), U3.9 (STAT1)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C13.2, C14.2, C15.2, C16.2, C22.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, D6.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.3 (PACK_MINUS), J3.5 (GND), Q3.2 (S), Q4.2 (S), Q6.2 (S), Q7.2 (S), R3.2, R6.2, R7.2, R10.2, R14.2, R22.2, R34.2, R35.2, R36.2, R39.2, R41.2, R42.2, R44.2, R49.2, R50.2, TH1.2 (RETURN), TP6.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U1.49 (VSS), U2.2 (GND), U3.5 (GND), U3.11 (EP), U4.2 (GND), U8.4 (SELECT), U8.5 (GND), U10.B1 (GND), U11.4 (VSS), U12.4 (VEE), U13.C1 (GND), U14.7 (GND), U14.11 (2CLK), U14.12 (2D), U14.13 (2CLR_N), U15.1 (GND); also elsewhere on the board
/ILIM_VSET: R42.1, U3.7 (ILIM_VSET)
/ISET: C30.1, R10.1, U3.8 (ISET)
/NRST: C9.1, J3.3 (nRESET), R2.2, U1.7 (NRST)
/PDM_CLK: R21.2, U8.3 (CLOCK)
/PDM_CLK_MCU: R21.1, U1.39 (PB3)
/PDM_DATA: U1.40 (PB4), U8.1 (DATA)
/SD_CLK: R23.2, U11.3 (CLK)
/SD_CLK_MCU: R23.1, U1.15 (PA5)
/SD_CS_N: R28.2, U1.14 (PA4), U11.2 (CS_N)
/SD_EN: R22.1, U1.41 (PB5), U10.B2 (ON)
/SD_MISO: R25.2, U1.16 (PA6), U11.6 (DO)
/SD_MOSI: R24.2, U1.17 (PA7), U11.5 (DI)
/SD_V3: C26.1, C27.1, R24.1, R25.1, R28.1, TP5.1, U10.A1 (VOUT), U11.8 (VDD)
/STATUS_LED: R32.1, U1.29 (PA8)
/STATUS_LED_A: D6.2 (A), R32.2
/SWCLK: J3.4 (SWCLK), U1.37 (PA14)
/SWDIO: J3.2 (SWDIO), U1.34 (PA13)
/SYS: C15.1, TP2.1, U3.1 (SYS), U4.1 (IN), U4.3 (EN)
/TS_COLD_REF: R38.2, R39.1, U12.3 (INA+)
/TS_HOT_REF: R40.2, R41.1, U12.6 (INB-)
/USB_DM: J1.A7 (D-), J1.B7 (D-), U1.32 (PA11), U2.3 (IO2), U2.4 (IO2)
/USB_DP: J1.A6 (D+), J1.B6 (D+), U1.33 (PA12), U2.1 (IO1), U2.6 (IO1)
/USB_ILIM_SET: R44.1, U13.C2 (SETI)
/USB_INPUT_ON: U13.A1 (ON), U14.6 (1Q_N)
/USB_LATCH_CLEAR_N: Q7.3 (D), R48.2, U14.1 (1CLR_N), U15.2 (RESET_N)
/USB_LATCH_CLOCK: Q6.3 (D), R47.2, U14.3 (1CLK)
/USB_RESUME_PULSE: Q7.1 (G), R50.1, U1.19 (PB1)
/USB_SUSPEND_PULSE: Q6.1 (G), R49.1, U1.12 (PA2)
/V3V3: C1.1, C2.1, C3.1, C4.1, C16.1, C22.1, C25.1, C29.1, J3.1 (VTref), R1.1, R2.1, R11.1, R15.1, R37.1, R38.1, R40.1, TP3.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U4.5 (OUT), U8.2 (VDD), U10.A2 (VIN), U12.8 (VCC); also elsewhere on the board
/VBUS: C31.1, C32.1, C33.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R13.1, R47.1, R48.1, U2.5 (VBUS), U13.B1 (IN), U14.2 (1D), U14.4 (1PRE_N), U14.10 (2PRE_N), U14.14 (VCC), U15.3 (VDD)
/VBUS_GATE: Q3.1 (G), R13.2, R14.1
/VBUS_LIMITED: C13.1, R12.1, U3.10 (IN), U13.B2 (OUT)
/VBUS_N: Q3.3 (D), R15.2, U1.10 (PA0)
/VCAP: C5.1, U1.22 (VCAP)
/VDDA: C6.1, C7.1, R1.2, U1.9 (VDDA)
unnamed 47: U1.38 (PA15); also elsewhere on the board

Notes on the sheet:
01 MCU / RTC / UI
02 USB-C / CHARGER
03 POWER / FUEL GAUGE
04 AUDIO / SD / INDICATORS
ENGINEERING DRAFT - NOT FOR FABRICATION - See hardware/xe-minimal/README.md

Schematic: pendant-xe-minimal.kicad_sch, Pendant Recorder - Omi-derived electrical design

Parts:
C1, C2, C3, C6, C9, C22, C26: 100n; C_0402_1005Metric
C4: 10u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C7, C16, C25: 1u; C_0402_1005Metric
C13: 2.2u 10V; C_0402_1005Metric
C14: 2.2u; C_0402_1005Metric
C15: 10u 10V effective >=1u; C_0603_1608Metric
C27: 4.7u effective TBD; C_0603_1608Metric
C28: 10n; C_0402_1005Metric
C29, C32, C33: 100n 10V; C_0402_1005Metric
C30: 50p 50V C0G; C_0402_1005Metric
C31: 1u 10V; C_0402_1005Metric
D6: APHHS1005LSYCK/J3-PF; APHHS1005LSYCK_J3_PF_V4B
J1: USB4105-GF-A (candidate); USB_C_GCT_USB4105_GroundLand112
J2: Molex781710003 / DTP401525-XE; Molex_Pico-EZmate_78171-0003_1x03-1MP_P1.20mm_Vertical
J3: Factory SWD pogo candidate; SWD_Pogo_5Pad_P1.27mm
Q3, Q4: DMN63D8L-7; SOT-23
Q6, Q7: 2N7002; SOT23_DMN2056U_DS38480
R1: 0R; R_0402_1005Metric
R2: 10k; R_0402_1005Metric
R3, R13, R15, R22: 100k; R_0402_1005Metric
R6, R7: 5.1k 1%; R_0402_1005Metric
R10: 6.8k 1%; R_0402_1005Metric
R11, R39: 20k 1%; R_0402_1005Metric
R12, R36, R37, R38, R40, R49, R50: 100k 1%; R_0402_1005Metric
R14: 1M; R_0402_1005Metric
R21, R23: 22R tentative; R_0402_1005Metric
R24, R25, R28: 47k; R_0402_1005Metric
R32: 6.8k tentative; R_0402_1005Metric
R33, R34: 1M 1%; R_0402_1005Metric
R35, R47, R48: 10k 1%; R_0402_1005Metric
R41: 7.5k 1%; R_0402_1005Metric
R42: 130k 1%; R_0402_1005Metric
R43: 4.7k 1%; R_0402_1005Metric
R44: 19.1k 0.1%; R_0402_1005Metric
TH1: NCP18XH103F03RB 10k 1% B3380 candidate; R_0603_1608Metric
TP1, TP2, TP3, TP5, TP6: TestPoint; TestPoint_Pad_D1.0mm
U1: STM32U535CEU6; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U2: USBLC6-2P6; SOT-666
U3: BQ25185DLHR; Texas_DLH0010A_WSON-10-1EP_2.2x2mm_P0.4mm_EP0.9x1.5mm
U4: TPS7A0233PDBVR; SOT-23-5
U8: IM69D130V01XTSA1; IM69D130_JLC_SMD_trial
U10: TPS22916CYFPR; TPS22916_YFP4
U11: CSNP32GCR01-BOW candidate; CSNP32GCR01_LGA8
U12: TLV7042DDFR; SOT-23-8
U13: TPS22950YBHR; TPS22950_YBH0006-C02_SMD_TI_4226594A
U14: SN74HCS74DYYR; Texas_DYY0014A
U15: TLV803EB29DBZR; SOT-23

Connections:
/BAT: C14.1, J2.1 (PACK_PLUS), R33.1, TP1.1, U3.2 (BAT)
/BAT_ADC: C28.1, R33.2, R34.1, U1.11 (PA1)
/BAT_TS: R37.2, TH1.1 (SENSE), U12.2 (INA-), U12.5 (INB+)
/BOOT0: R3.1, U1.44 (PH3)
/CC1: J1.A5 (CC1), R6.1
/CC2: J1.B5 (CC2), R7.1
/CHARGER_TS: R35.1, U3.6 (TS_MR)
/CHG_ALLOW: R43.1, U1.20 (PB2)
/CHG_GUARD_GATE: Q4.1 (G), R36.1, R43.2, U12.1 (OUTA), U12.7 (OUTB)
/CHG_INHIBIT_GATE: Q4.3 (D), R12.2, U3.4 (CE_N)
/CHG_N: R11.2, U1.27 (PB14), U3.9 (STAT1)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C13.2, C14.2, C15.2, C16.2, C22.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, D6.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.3 (PACK_MINUS), J3.5 (GND), Q3.2 (S), Q4.2 (S), Q6.2 (S), Q7.2 (S), R3.2, R6.2, R7.2, R10.2, R14.2, R22.2, R34.2, R35.2, R36.2, R39.2, R41.2, R42.2, R44.2, R49.2, R50.2, TH1.2 (RETURN), TP6.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U1.49 (VSS), U2.2 (GND), U3.5 (GND), U3.11 (EP), U4.2 (GND), U8.4 (SELECT), U8.5 (GND), U10.B1 (GND), U11.4 (VSS), U12.4 (VEE), U13.C1 (GND), U14.7 (GND), U14.11 (2CLK), U14.12 (2D), U14.13 (2CLR_N), U15.1 (GND); also elsewhere on the board
/ILIM_VSET: R42.1, U3.7 (ILIM_VSET)
/ISET: C30.1, R10.1, U3.8 (ISET)
/NRST: C9.1, J3.3 (nRESET), R2.2, U1.7 (NRST)
/PDM_CLK: R21.2, U8.3 (CLOCK)
/PDM_CLK_MCU: R21.1, U1.39 (PB3)
/PDM_DATA: U1.40 (PB4), U8.1 (DATA)
/SD_CLK: R23.2, U11.3 (CLK)
/SD_CLK_MCU: R23.1, U1.15 (PA5)
/SD_CS_N: R28.2, U1.14 (PA4), U11.2 (CS_N)
/SD_EN: R22.1, U1.41 (PB5), U10.B2 (ON)
/SD_MISO: R25.2, U1.16 (PA6), U11.6 (DO)
/SD_MOSI: R24.2, U1.17 (PA7), U11.5 (DI)
/SD_V3: C26.1, C27.1, R24.1, R25.1, R28.1, TP5.1, U10.A1 (VOUT), U11.8 (VDD)
/STATUS_LED: R32.1, U1.29 (PA8)
/STATUS_LED_A: D6.2 (A), R32.2
/SWCLK: J3.4 (SWCLK), U1.37 (PA14)
/SWDIO: J3.2 (SWDIO), U1.34 (PA13)
/SYS: C15.1, TP2.1, U3.1 (SYS), U4.1 (IN), U4.3 (EN)
/TS_COLD_REF: R38.2, R39.1, U12.3 (INA+)
/TS_HOT_REF: R40.2, R41.1, U12.6 (INB-)
/USB_DM: J1.A7 (D-), J1.B7 (D-), U1.32 (PA11), U2.3 (IO2), U2.4 (IO2)
/USB_DP: J1.A6 (D+), J1.B6 (D+), U1.33 (PA12), U2.1 (IO1), U2.6 (IO1)
/USB_ILIM_SET: R44.1, U13.C2 (SETI)
/USB_INPUT_ON: U13.A1 (ON), U14.6 (1Q_N)
/USB_LATCH_CLEAR_N: Q7.3 (D), R48.2, U14.1 (1CLR_N), U15.2 (RESET_N)
/USB_LATCH_CLOCK: Q6.3 (D), R47.2, U14.3 (1CLK)
/USB_RESUME_PULSE: Q7.1 (G), R50.1, U1.19 (PB1)
/USB_SUSPEND_PULSE: Q6.1 (G), R49.1, U1.12 (PA2)
/V3V3: C1.1, C2.1, C3.1, C4.1, C16.1, C22.1, C25.1, C29.1, J3.1 (VTref), R1.1, R2.1, R11.1, R15.1, R37.1, R38.1, R40.1, TP3.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U4.5 (OUT), U8.2 (VDD), U10.A2 (VIN), U12.8 (VCC); also elsewhere on the board
/VBUS: C31.1, C32.1, C33.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R13.1, R47.1, R48.1, U2.5 (VBUS), U13.B1 (IN), U14.2 (1D), U14.4 (1PRE_N), U14.10 (2PRE_N), U14.14 (VCC), U15.3 (VDD)
/VBUS_GATE: Q3.1 (G), R13.2, R14.1
/VBUS_LIMITED: C13.1, R12.1, U3.10 (IN), U13.B2 (OUT)
/VBUS_N: Q3.3 (D), R15.2, U1.10 (PA0)
/VCAP: C5.1, U1.22 (VCAP)
/VDDA: C6.1, C7.1, R1.2, U1.9 (VDDA)
unnamed 47: U1.38 (PA15); also elsewhere on the board

Notes on the sheet:
01 MCU / RTC / UI
02 USB-C / CHARGER
03 POWER / FUEL GAUGE
04 AUDIO / SD / INDICATORS
ENGINEERING DRAFT - NOT FOR FABRICATION - See hardware/xe-minimal/README.md

Schematic: pendant-xe-minimal.kicad_sch, Pendant Recorder - Omi-derived electrical design

Parts:
C1, C2, C3, C6, C9, C22, C26: 100n; C_0402_1005Metric
C4: 10u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C7, C16, C25: 1u; C_0402_1005Metric
C13: 2.2u 10V; C_0402_1005Metric
C14: 2.2u; C_0402_1005Metric
C15: 10u 10V effective >=1u; C_0603_1608Metric
C27: 4.7u effective TBD; C_0603_1608Metric
C28: 10n; C_0402_1005Metric
C29, C32, C33: 100n 10V; C_0402_1005Metric
C30: 50p 50V C0G; C_0402_1005Metric
C31: 1u 10V; C_0402_1005Metric
D6: APHHS1005LSYCK/J3-PF; APHHS1005LSYCK_J3_PF_V4B
J1: USB4105-GF-A (candidate); USB_C_GCT_USB4105_GroundLand112
J2: Molex781710003 / DTP401525-XE; Molex_Pico-EZmate_78171-0003_1x03-1MP_P1.20mm_Vertical
J3: Factory SWD pogo candidate; SWD_Pogo_5Pad_P1.27mm
Q3, Q4: DMN63D8L-7; SOT-23
Q6, Q7: 2N7002; SOT23_DMN2056U_DS38480
R1: 0R; R_0402_1005Metric
R2: 10k; R_0402_1005Metric
R3, R13, R15, R22: 100k; R_0402_1005Metric
R6, R7: 5.1k 1%; R_0402_1005Metric
R10: 6.8k 1%; R_0402_1005Metric
R11, R39: 20k 1%; R_0402_1005Metric
R12, R36, R37, R38, R40, R49, R50: 100k 1%; R_0402_1005Metric
R14: 1M; R_0402_1005Metric
R21, R23: 22R tentative; R_0402_1005Metric
R24, R25, R28: 47k; R_0402_1005Metric
R32: 6.8k tentative; R_0402_1005Metric
R33, R34: 1M 1%; R_0402_1005Metric
R35, R47, R48: 10k 1%; R_0402_1005Metric
R41: 7.5k 1%; R_0402_1005Metric
R42: 130k 1%; R_0402_1005Metric
R43: 4.7k 1%; R_0402_1005Metric
R44: 19.1k 0.1%; R_0402_1005Metric
TH1: NCU18XH103F60RB 10k 1% B3380 candidate; R_0603_1608Metric
TP1, TP2, TP3, TP5, TP6: TestPoint; TestPoint_Pad_D1.0mm
U1: STM32U535CEU6; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U2: USBLC6-2P6; SOT-666
U3: BQ25185DLHR; Texas_DLH0010A_WSON-10-1EP_2.2x2mm_P0.4mm_EP0.9x1.5mm
U4: TPS7A0233PDBVR; SOT-23-5
U8: IM69D130V01XTSA1; IM69D130_JLC_SMD_trial
U10: TPS22916CYFPR; TPS22916_YFP4
U11: CSNP32GCR01-BOW candidate; CSNP32GCR01_LGA8
U12: TLV7042DDFR; SOT-23-8
U13: TPS22950YBHR; TPS22950_YBH0006-C02_SMD_TI_4226594A
U14: SN74HCS74DYYR; Texas_DYY0014A
U15: TLV803EB29DBZR; SOT-23

Connections:
/BAT: C14.1, J2.1 (PACK_PLUS), R33.1, TP1.1, U3.2 (BAT)
/BAT_ADC: C28.1, R33.2, R34.1, U1.11 (PA1)
/BAT_TS: R37.2, TH1.1 (SENSE), U12.2 (INA-), U12.5 (INB+)
/BOOT0: R3.1, U1.44 (PH3)
/CC1: J1.A5 (CC1), R6.1
/CC2: J1.B5 (CC2), R7.1
/CHARGER_TS: R35.1, U3.6 (TS_MR)
/CHG_ALLOW: R43.1, U1.20 (PB2)
/CHG_GUARD_GATE: Q4.1 (G), R36.1, R43.2, U12.1 (OUTA), U12.7 (OUTB)
/CHG_INHIBIT_GATE: Q4.3 (D), R12.2, U3.4 (CE_N)
/CHG_N: R11.2, U1.27 (PB14), U3.9 (STAT1)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C13.2, C14.2, C15.2, C16.2, C22.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, D6.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.3 (PACK_MINUS), J3.5 (GND), Q3.2 (S), Q4.2 (S), Q6.2 (S), Q7.2 (S), R3.2, R6.2, R7.2, R10.2, R14.2, R22.2, R34.2, R35.2, R36.2, R39.2, R41.2, R42.2, R44.2, R49.2, R50.2, TH1.2 (RETURN), TP6.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U1.49 (VSS), U2.2 (GND), U3.5 (GND), U3.11 (EP), U4.2 (GND), U8.4 (SELECT), U8.5 (GND), U10.B1 (GND), U11.4 (VSS), U12.4 (VEE), U13.C1 (GND), U14.7 (GND), U14.11 (2CLK), U14.12 (2D), U14.13 (2CLR_N), U15.1 (GND); also elsewhere on the board
/ILIM_VSET: R42.1, U3.7 (ILIM_VSET)
/ISET: C30.1, R10.1, U3.8 (ISET)
/NRST: C9.1, J3.3 (nRESET), R2.2, U1.7 (NRST)
/PDM_CLK: R21.2, U8.3 (CLOCK)
/PDM_CLK_MCU: R21.1, U1.39 (PB3)
/PDM_DATA: U1.40 (PB4), U8.1 (DATA)
/SD_CLK: R23.2, U11.3 (CLK)
/SD_CLK_MCU: R23.1, U1.15 (PA5)
/SD_CS_N: R28.2, U1.14 (PA4), U11.2 (CS_N)
/SD_EN: R22.1, U1.41 (PB5), U10.B2 (ON)
/SD_MISO: R25.2, U1.16 (PA6), U11.6 (DO)
/SD_MOSI: R24.2, U1.17 (PA7), U11.5 (DI)
/SD_V3: C26.1, C27.1, R24.1, R25.1, R28.1, TP5.1, U10.A1 (VOUT), U11.8 (VDD)
/STATUS_LED: R32.1, U1.29 (PA8)
/STATUS_LED_A: D6.2 (A), R32.2
/SWCLK: J3.4 (SWCLK), U1.37 (PA14)
/SWDIO: J3.2 (SWDIO), U1.34 (PA13)
/SYS: C15.1, TP2.1, U3.1 (SYS), U4.1 (IN), U4.3 (EN)
/TS_COLD_REF: R38.2, R39.1, U12.3 (INA+)
/TS_HOT_REF: R40.2, R41.1, U12.6 (INB-)
/USB_DM: J1.A7 (D-), J1.B7 (D-), U1.32 (PA11), U2.3 (IO2), U2.4 (IO2)
/USB_DP: J1.A6 (D+), J1.B6 (D+), U1.33 (PA12), U2.1 (IO1), U2.6 (IO1)
/USB_ILIM_SET: R44.1, U13.C2 (SETI)
/USB_INPUT_ON: U13.A1 (ON), U14.6 (1Q_N)
/USB_LATCH_CLEAR_N: Q7.3 (D), R48.2, U14.1 (1CLR_N), U15.2 (RESET_N)
/USB_LATCH_CLOCK: Q6.3 (D), R47.2, U14.3 (1CLK)
/USB_RESUME_PULSE: Q7.1 (G), R50.1, U1.19 (PB1)
/USB_SUSPEND_PULSE: Q6.1 (G), R49.1, U1.12 (PA2)
/V3V3: C1.1, C2.1, C3.1, C4.1, C16.1, C22.1, C25.1, C29.1, J3.1 (VTref), R1.1, R2.1, R11.1, R15.1, R37.1, R38.1, R40.1, TP3.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U4.5 (OUT), U8.2 (VDD), U10.A2 (VIN), U12.8 (VCC); also elsewhere on the board
/VBUS: C31.1, C32.1, C33.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R13.1, R47.1, R48.1, U2.5 (VBUS), U13.B1 (IN), U14.2 (1D), U14.4 (1PRE_N), U14.10 (2PRE_N), U14.14 (VCC), U15.3 (VDD)
/VBUS_GATE: Q3.1 (G), R13.2, R14.1
/VBUS_LIMITED: C13.1, R12.1, U3.10 (IN), U13.B2 (OUT)
/VBUS_N: Q3.3 (D), R15.2, U1.10 (PA0)
/VCAP: C5.1, U1.22 (VCAP)
/VDDA: C6.1, C7.1, R1.2, U1.9 (VDDA)
unnamed 47: U1.38 (PA15); also elsewhere on the board

Notes on the sheet:
01 MCU / RTC / UI
02 USB-C / CHARGER
03 POWER / FUEL GAUGE
04 AUDIO / SD / INDICATORS
ENGINEERING DRAFT - NOT FOR FABRICATION - See hardware/xe-minimal/README.md

Schematic: pendant-xe-minimal.kicad_sch, Pendant Recorder - Omi-derived electrical design

Parts:
C1, C2, C3, C6, C9, C22, C26: 100n; C_0402_1005Metric
C4: 10u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C7, C16, C25: 1u; C_0402_1005Metric
C13: 2.2u 10V; C_0402_1005Metric
C14: 2.2u; C_0402_1005Metric
C15: 10u 10V effective >=1u; C_0603_1608Metric
C27: 4.7u effective TBD; C_0603_1608Metric
C28: 10n; C_0402_1005Metric
C29, C32, C33: 100n 10V; C_0402_1005Metric
C30: 50p 50V C0G; C_0402_1005Metric
C31: 1u 10V; C_0402_1005Metric
D6: APHHS1005LSYCK/J3-PF; APHHS1005LSYCK_J3_PF_V4B
J1: USB4105-GF-A (candidate); USB_C_GCT_USB4105_GroundLand112
J2: Molex781710003 / DTP401525-XE; Molex_Pico-EZmate_78171-0003_1x03-1MP_P1.20mm_Vertical
J3: Factory SWD pogo candidate; SWD_Pogo_5Pad_P1.27mm
Q3, Q4: DMN63D8L-7; SOT-23
Q6, Q7: 2N7002; SOT-23
R1: 0R; R_0402_1005Metric
R2: 10k; R_0402_1005Metric
R3, R13, R15, R22: 100k; R_0402_1005Metric
R6, R7: 5.1k 1%; R_0402_1005Metric
R10: 6.8k 1%; R_0402_1005Metric
R11, R39: 20k 1%; R_0402_1005Metric
R12, R36, R37, R38, R40, R49, R50: 100k 1%; R_0402_1005Metric
R14: 1M; R_0402_1005Metric
R21, R23: 22R tentative; R_0402_1005Metric
R24, R25, R28: 47k; R_0402_1005Metric
R32: 6.8k tentative; R_0402_1005Metric
R33, R34: 1M 1%; R_0402_1005Metric
R35, R47, R48: 10k 1%; R_0402_1005Metric
R41: 7.5k 1%; R_0402_1005Metric
R42: 130k 1%; R_0402_1005Metric
R43: 4.7k 1%; R_0402_1005Metric
R44: 19.1k 0.1%; R_0402_1005Metric
TH1: NCP18XH103F03RB 10k 1% B3380 candidate; R_0603_1608Metric
TP1, TP2, TP3, TP5, TP6: TestPoint; TestPoint_Pad_D1.0mm
U1: STM32U535CEU6; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U2: USBLC6-2P6; SOT-666
U3: BQ25185DLHR; Texas_DLH0010A_WSON-10-1EP_2.2x2mm_P0.4mm_EP0.9x1.5mm
U4: TPS7A0233PDBVR; SOT-23-5
U8: IM69D130V01XTSA1; IM69D130_JLC_SMD_trial
U10: TPS22916CYFPR; TPS22916_YFP4
U11: CSNP32GCR01-BOW candidate; CSNP32GCR01_LGA8
U12: TLV7042DDFR; SOT-23-8
U13: TPS22950YBHR; TPS22950_YBH0006-C02_SMD_TI_4226594A
U14: SN74HCS74DYYR; Texas_DYY0014A
U15: TLV803EB29DBZR; SOT-23

Connections:
/BAT: C14.1, J2.1 (PACK_PLUS), R33.1, TP1.1, U3.2 (BAT)
/BAT_ADC: C28.1, R33.2, R34.1, U1.11 (PA1)
/BAT_TS: R37.2, TH1.1 (SENSE), U12.2 (INA-), U12.5 (INB+)
/BOOT0: R3.1, U1.44 (PH3)
/CC1: J1.A5 (CC1), R6.1
/CC2: J1.B5 (CC2), R7.1
/CHARGER_TS: R35.1, U3.6 (TS_MR)
/CHG_ALLOW: R43.1, U1.20 (PB2)
/CHG_GUARD_GATE: Q4.1 (G), R36.1, R43.2, U12.1 (OUTA), U12.7 (OUTB)
/CHG_INHIBIT_GATE: Q4.3 (D), R12.2, U3.4 (CE_N)
/CHG_N: R11.2, U1.27 (PB14), U3.9 (STAT1)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C13.2, C14.2, C15.2, C16.2, C22.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, D6.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.3 (PACK_MINUS), J3.5 (GND), Q3.2 (S), Q4.2 (S), Q6.2 (S), Q7.2 (S), R3.2, R6.2, R7.2, R10.2, R14.2, R22.2, R34.2, R35.2, R36.2, R39.2, R41.2, R42.2, R44.2, R49.2, R50.2, TH1.2 (RETURN), TP6.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U1.49 (VSS), U2.2 (GND), U3.5 (GND), U3.11 (EP), U4.2 (GND), U8.4 (SELECT), U8.5 (GND), U10.B1 (GND), U11.4 (VSS), U12.4 (VEE), U13.C1 (GND), U14.7 (GND), U14.11 (2CLK), U14.12 (2D), U14.13 (2CLR_N), U15.1 (GND); also elsewhere on the board
/ILIM_VSET: R42.1, U3.7 (ILIM_VSET)
/ISET: C30.1, R10.1, U3.8 (ISET)
/NRST: C9.1, J3.3 (nRESET), R2.2, U1.7 (NRST)
/PDM_CLK: R21.2, U8.3 (CLOCK)
/PDM_CLK_MCU: R21.1, U1.39 (PB3)
/PDM_DATA: U1.40 (PB4), U8.1 (DATA)
/SD_CLK: R23.2, U11.3 (CLK)
/SD_CLK_MCU: R23.1, U1.15 (PA5)
/SD_CS_N: R28.2, U1.14 (PA4), U11.2 (CS_N)
/SD_EN: R22.1, U1.41 (PB5), U10.B2 (ON)
/SD_MISO: R25.2, U1.16 (PA6), U11.6 (DO)
/SD_MOSI: R24.2, U1.17 (PA7), U11.5 (DI)
/SD_V3: C26.1, C27.1, R24.1, R25.1, R28.1, TP5.1, U10.A1 (VOUT), U11.8 (VDD)
/STATUS_LED: R32.1, U1.29 (PA8)
/STATUS_LED_A: D6.2 (A), R32.2
/SWCLK: J3.4 (SWCLK), U1.37 (PA14)
/SWDIO: J3.2 (SWDIO), U1.34 (PA13)
/SYS: C15.1, TP2.1, U3.1 (SYS), U4.1 (IN), U4.3 (EN)
/TS_COLD_REF: R38.2, R39.1, U12.3 (INA+)
/TS_HOT_REF: R40.2, R41.1, U12.6 (INB-)
/USB_DM: J1.A7 (D-), J1.B7 (D-), U1.32 (PA11), U2.3 (IO2), U2.4 (IO2)
/USB_DP: J1.A6 (D+), J1.B6 (D+), U1.33 (PA12), U2.1 (IO1), U2.6 (IO1)
/USB_ILIM_SET: R44.1, U13.C2 (SETI)
/USB_INPUT_ON: U13.A1 (ON), U14.6 (1Q_N)
/USB_LATCH_CLEAR_N: Q7.3 (D), R48.2, U14.1 (1CLR_N), U15.2 (RESET_N)
/USB_LATCH_CLOCK: Q6.3 (D), R47.2, U14.3 (1CLK)
/USB_RESUME_PULSE: Q7.1 (G), R50.1, U1.19 (PB1)
/USB_SUSPEND_PULSE: Q6.1 (G), R49.1, U1.12 (PA2)
/V3V3: C1.1, C2.1, C3.1, C4.1, C16.1, C22.1, C25.1, C29.1, J3.1 (VTref), R1.1, R2.1, R11.1, R15.1, R37.1, R38.1, R40.1, TP3.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U4.5 (OUT), U8.2 (VDD), U10.A2 (VIN), U12.8 (VCC); also elsewhere on the board
/VBUS: C31.1, C32.1, C33.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R13.1, R47.1, R48.1, U2.5 (VBUS), U13.B1 (IN), U14.2 (1D), U14.4 (1PRE_N), U14.10 (2PRE_N), U14.14 (VCC), U15.3 (VDD)
/VBUS_GATE: Q3.1 (G), R13.2, R14.1
/VBUS_LIMITED: C13.1, R12.1, U3.10 (IN), U13.B2 (OUT)
/VBUS_N: Q3.3 (D), R15.2, U1.10 (PA0)
/VCAP: C5.1, U1.22 (VCAP)
/VDDA: C6.1, C7.1, R1.2, U1.9 (VDDA)
unnamed 47: U1.38 (PA15); also elsewhere on the board

Notes on the sheet:
01 MCU / RTC / UI
02 USB-C / CHARGER
03 POWER / FUEL GAUGE
04 AUDIO / SD / INDICATORS
ENGINEERING DRAFT - NOT FOR FABRICATION - See hardware/xe-minimal/README.md

Schematic: pendant-xe-minimal.kicad_sch, Pendant Recorder - Omi-derived electrical design

Parts:
C1, C2, C3, C6, C9, C22, C26: 100n; C_0402_1005Metric
C4: 10u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C7, C16, C25: 1u; C_0402_1005Metric
C13: 2.2u 10V; C_0402_1005Metric
C14: 2.2u; C_0402_1005Metric
C15: 10u 10V effective >=1u; C_0603_1608Metric
C27: 4.7u effective TBD; C_0603_1608Metric
C28: 10n; C_0402_1005Metric
C29, C32, C33: 100n 10V; C_0402_1005Metric
C30: 50p 50V C0G; C_0402_1005Metric
C31: 1u 10V; C_0402_1005Metric
D6: amber LED 0402 TBD; LED_0402_1005Metric
J1: USB4105-GF-A (candidate); USB_C_GCT_USB4105_GroundLand112
J2: Molex781710003 / DTP401525-XE; Molex_Pico-EZmate_78171-0003_1x03-1MP_P1.20mm_Vertical
J3: Factory SWD pogo candidate; SWD_Pogo_5Pad_P1.27mm
Q3, Q4: DMN63D8L-7; SOT-23
Q6, Q7: 2N7002; SOT-23
R1: 0R; R_0402_1005Metric
R2: 10k; R_0402_1005Metric
R3, R4, R13, R15, R22: 100k; R_0402_1005Metric
R6, R7: 5.1k 1%; R_0402_1005Metric
R10: 6.8k 1%; R_0402_1005Metric
R11, R39: 20k 1%; R_0402_1005Metric
R12, R36, R37, R38, R40, R49, R50: 100k 1%; R_0402_1005Metric
R14: 1M; R_0402_1005Metric
R21, R23: 22R tentative; R_0402_1005Metric
R24, R25, R28: 47k; R_0402_1005Metric
R32: 6.8k tentative; R_0402_1005Metric
R33, R34: 1M 1%; R_0402_1005Metric
R35, R47, R48: 10k 1%; R_0402_1005Metric
R41: 7.5k 1%; R_0402_1005Metric
R42: 130k 1%; R_0402_1005Metric
R43: 4.7k 1%; R_0402_1005Metric
R44: 19.1k 0.1%; R_0402_1005Metric
SW1: B3U-1000P (candidate); SW_SPST_B3U-1000P
TH1: NCP18XH103F03RB 10k 1% B3380 candidate; R_0603_1608Metric
TP1, TP2, TP3, TP5, TP6: TestPoint; TestPoint_Pad_D1.0mm
U1: STM32U535CEU6; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U2: USBLC6-2P6; SOT-666
U3: BQ25185DLHR; Texas_DLH0010A_WSON-10-1EP_2.2x2mm_P0.4mm_EP0.9x1.5mm
U4: TPS7A0233PDBVR; SOT-23-5
U8: IM69D130V01XTSA1; IM69D130_JLC_SMD_trial
U10: TPS22916CYFPR; TPS22916_YFP4
U11: CSNP32GCR01-BOW candidate; CSNP32GCR01_LGA8
U12: TLV7042DDFR; SOT-23-8
U13: TPS22950YBHR; TPS22950_YBH0006-C02_SMD_TI_4226594A
U14: SN74HCS74DYYR; Texas_DYY0014A
U15: TLV803EB29DBZR; SOT-23

Connections:
/BAT: C14.1, J2.1 (PACK_PLUS), R33.1, TP1.1, U3.2 (BAT)
/BAT_ADC: C28.1, R33.2, R34.1, U1.11 (PA1)
/BAT_TS: R37.2, TH1.1 (SENSE), U12.2 (INA-), U12.5 (INB+)
/BOOT0: R3.1, U1.44 (PH3)
/CC1: J1.A5 (CC1), R6.1
/CC2: J1.B5 (CC2), R7.1
/CHARGER_TS: R35.1, U3.6 (TS_MR)
/CHG_ALLOW: R43.1, U1.20 (PB2)
/CHG_GUARD_GATE: Q4.1 (G), R36.1, R43.2, U12.1 (OUTA), U12.7 (OUTB)
/CHG_INHIBIT_GATE: Q4.3 (D), R12.2, U3.4 (CE_N)
/CHG_N: R11.2, U1.27 (PB14), U3.9 (STAT1)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C13.2, C14.2, C15.2, C16.2, C22.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, D6.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.3 (PACK_MINUS), J3.5 (GND), Q3.2 (S), Q4.2 (S), Q6.2 (S), Q7.2 (S), R3.2, R6.2, R7.2, R10.2, R14.2, R22.2, R34.2, R35.2, R36.2, R39.2, R41.2, R42.2, R44.2, R49.2, R50.2, SW1.2, TH1.2 (RETURN), TP6.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U1.49 (VSS), U2.2 (GND), U3.5 (GND), U3.11 (EP), U4.2 (GND), U8.4 (SELECT), U8.5 (GND), U10.B1 (GND), U11.4 (VSS), U12.4 (VEE), U13.C1 (GND), U14.7 (GND), U14.11 (2CLK), U14.12 (2D), U14.13 (2CLR_N), U15.1 (GND)
/ILIM_VSET: R42.1, U3.7 (ILIM_VSET)
/ISET: C30.1, R10.1, U3.8 (ISET)
/NRST: C9.1, J3.3 (nRESET), R2.2, U1.7 (NRST)
/PDM_CLK: R21.2, U8.3 (CLOCK)
/PDM_CLK_MCU: R21.1, U1.39 (PB3)
/PDM_DATA: U1.40 (PB4), U8.1 (DATA)
/SD_CLK: R23.2, U11.3 (CLK)
/SD_CLK_MCU: R23.1, U1.15 (PA5)
/SD_CS_N: R28.2, U1.14 (PA4), U11.2 (CS_N)
/SD_EN: R22.1, U1.41 (PB5), U10.B2 (ON)
/SD_MISO: R25.2, U1.16 (PA6), U11.6 (DO)
/SD_MOSI: R24.2, U1.17 (PA7), U11.5 (DI)
/SD_V3: C26.1, C27.1, R24.1, R25.1, R28.1, TP5.1, U10.A1 (VOUT), U11.8 (VDD)
/STATUS_LED: R32.1, U1.29 (PA8)
/STATUS_LED_A: D6.2 (A), R32.2
/SWCLK: J3.4 (SWCLK), U1.37 (PA14)
/SWDIO: J3.2 (SWDIO), U1.34 (PA13)
/SYS: C15.1, TP2.1, U3.1 (SYS), U4.1 (IN), U4.3 (EN)
/TS_COLD_REF: R38.2, R39.1, U12.3 (INA+)
/TS_HOT_REF: R40.2, R41.1, U12.6 (INB-)
/USB_DM: J1.A7 (D-), J1.B7 (D-), U1.32 (PA11), U2.3 (IO2), U2.4 (IO2)
/USB_DP: J1.A6 (D+), J1.B6 (D+), U1.33 (PA12), U2.1 (IO1), U2.6 (IO1)
/USB_ILIM_SET: R44.1, U13.C2 (SETI)
/USB_INPUT_ON: U13.A1 (ON), U14.6 (1Q_N)
/USB_LATCH_CLEAR_N: Q7.3 (D), R48.2, U14.1 (1CLR_N), U15.2 (RESET_N)
/USB_LATCH_CLOCK: Q6.3 (D), R47.2, U14.3 (1CLK)
/USB_RESUME_PULSE: Q7.1 (G), R50.1, U1.19 (PB1)
/USB_SUSPEND_PULSE: Q6.1 (G), R49.1, U1.12 (PA2)
/V3V3: C1.1, C2.1, C3.1, C4.1, C16.1, C22.1, C25.1, C29.1, J3.1 (VTref), R1.1, R2.1, R4.1, R11.1, R15.1, R37.1, R38.1, R40.1, TP3.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U4.5 (OUT), U8.2 (VDD), U10.A2 (VIN), U12.8 (VCC)
/VBUS: C31.1, C32.1, C33.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R13.1, R47.1, R48.1, U2.5 (VBUS), U13.B1 (IN), U14.2 (1D), U14.4 (1PRE_N), U14.10 (2PRE_N), U14.14 (VCC), U15.3 (VDD)
/VBUS_GATE: Q3.1 (G), R13.2, R14.1
/VBUS_LIMITED: C13.1, R12.1, U3.10 (IN), U13.B2 (OUT)
/VBUS_N: Q3.3 (D), R15.2, U1.10 (PA0)
/VCAP: C5.1, U1.22 (VCAP)
/VDDA: C6.1, C7.1, R1.2, U1.9 (VDDA)
unnamed: R4.2, SW1.1, U1.38 (PA15)

Notes on the sheet:
01 MCU / RTC / UI
02 USB-C / CHARGER
03 POWER / FUEL GAUGE
04 AUDIO / SD / INDICATORS
ENGINEERING DRAFT - NOT FOR FABRICATION - See hardware/xe-minimal/README.md

Schematic: pendant-xe-minimal.kicad_sch, Pendant Recorder - Omi-derived electrical design

Parts:
C1, C2, C3, C6, C9, C22, C26: 100n; C_0402_1005Metric
C4: 10u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C7, C16, C25: 1u; C_0402_1005Metric
C13: 2.2u 10V; C_0402_1005Metric
C14: 2.2u; C_0402_1005Metric
C15: 10u 10V effective >=1u; C_0603_1608Metric
C27: 4.7u effective TBD; C_0603_1608Metric
C28: 10n; C_0402_1005Metric
C29, C32, C33: 100n 10V; C_0402_1005Metric
C30: 50p 50V C0G; C_0402_1005Metric
C31: 1u 10V; C_0402_1005Metric
D6: amber LED 0402 TBD; LED_0402_1005Metric
J1: USB4105-GF-A (candidate); USB_C_GCT_USB4105_GroundLand112
J2: Molex781710003 / DTP401525-XE; Molex_Pico-EZmate_78171-0003_1x03-1MP_P1.20mm_Vertical
J3: Factory SWD pogo candidate; SWD_Pogo_5Pad_P1.27mm
Q3, Q4: DMN63D8L-7; SOT-23
Q6, Q7: 2N7002; SOT-23
R1: 0R; R_0402_1005Metric
R2: 10k; R_0402_1005Metric
R3, R4, R13, R15, R22: 100k; R_0402_1005Metric
R6, R7: 5.1k 1%; R_0402_1005Metric
R10: 6.8k 1%; R_0402_1005Metric
R11, R39: 20k 1%; R_0402_1005Metric
R12, R36, R37, R38, R40, R49, R50: 100k 1%; R_0402_1005Metric
R14: 1M; R_0402_1005Metric
R21, R23: 22R tentative; R_0402_1005Metric
R24, R25, R28: 47k; R_0402_1005Metric
R32: 6.8k tentative; R_0402_1005Metric
R33, R34: 1M 1%; R_0402_1005Metric
R35, R47, R48: 10k 1%; R_0402_1005Metric
R41: 7.5k 1%; R_0402_1005Metric
R42: 130k 1%; R_0402_1005Metric
R43: 4.7k 1%; R_0402_1005Metric
R44: 19.2k 0.1%; R_0402_1005Metric
SW1: B3U-1000P (candidate); SW_SPST_B3U-1000P
TH1: NCP18XH103F03RB 10k 1% B3380 candidate; R_0603_1608Metric
TP1, TP2, TP3, TP5, TP6: TestPoint; TestPoint_Pad_D1.0mm
U1: STM32U535CEU6; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U2: USBLC6-2P6; SOT-666
U3: BQ25185DLHR; Texas_DLH0010A_WSON-10-1EP_2.2x2mm_P0.4mm_EP0.9x1.5mm
U4: TPS7A0233PDBVR; SOT-23-5
U8: IM69D130V01XTSA1; IM69D130_JLC_SMD_trial
U10: TPS22916CYFPR; TPS22916_YFP4
U11: CSNP32GCR01-BOW candidate; CSNP32GCR01_LGA8
U12: TLV7042DDFR; SOT-23-8
U13: TPS22950YBHR; TPS22950_YBH0006-C02_SMD_TI_4226594A
U14: SN74HCS74DYYR; Texas_DYY0014A
U15: TLV803EB29DBZR; SOT-23

Connections:
/BAT: C14.1, J2.1 (PACK_PLUS), R33.1, TP1.1, U3.2 (BAT)
/BAT_ADC: C28.1, R33.2, R34.1, U1.11 (PA1)
/BAT_TS: R37.2, TH1.1 (SENSE), U12.2 (INA-), U12.5 (INB+)
/BOOT0: R3.1, U1.44 (PH3)
/CC1: J1.A5 (CC1), R6.1
/CC2: J1.B5 (CC2), R7.1
/CHARGER_TS: R35.1, U3.6 (TS_MR)
/CHG_ALLOW: R43.1, U1.20 (PB2)
/CHG_GUARD_GATE: Q4.1 (G), R36.1, R43.2, U12.1 (OUTA), U12.7 (OUTB)
/CHG_INHIBIT_GATE: Q4.3 (D), R12.2, U3.4 (CE_N)
/CHG_N: R11.2, U1.27 (PB14), U3.9 (STAT1)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C13.2, C14.2, C15.2, C16.2, C22.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, D6.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.3 (PACK_MINUS), J3.5 (GND), Q3.2 (S), Q4.2 (S), Q6.2 (S), Q7.2 (S), R3.2, R6.2, R7.2, R10.2, R14.2, R22.2, R34.2, R35.2, R36.2, R39.2, R41.2, R42.2, R44.2, R49.2, R50.2, SW1.2, TH1.2 (RETURN), TP6.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U1.49 (VSS), U2.2 (GND), U3.5 (GND), U3.11 (EP), U4.2 (GND), U8.4 (SELECT), U8.5 (GND), U10.B1 (GND), U11.4 (VSS), U12.4 (VEE), U13.C1 (GND), U14.7 (GND), U14.11 (2CLK), U14.12 (2D), U14.13 (2CLR_N), U15.1 (GND)
/ILIM_VSET: R42.1, U3.7 (ILIM_VSET)
/ISET: C30.1, R10.1, U3.8 (ISET)
/NRST: C9.1, J3.3 (nRESET), R2.2, U1.7 (NRST)
/PDM_CLK: R21.2, U8.3 (CLOCK)
/PDM_CLK_MCU: R21.1, U1.39 (PB3)
/PDM_DATA: U1.40 (PB4), U8.1 (DATA)
/SD_CLK: R23.2, U11.3 (CLK)
/SD_CLK_MCU: R23.1, U1.15 (PA5)
/SD_CS_N: R28.2, U1.14 (PA4), U11.2 (CS_N)
/SD_EN: R22.1, U1.41 (PB5), U10.B2 (ON)
/SD_MISO: R25.2, U1.16 (PA6), U11.6 (DO)
/SD_MOSI: R24.2, U1.17 (PA7), U11.5 (DI)
/SD_V3: C26.1, C27.1, R24.1, R25.1, R28.1, TP5.1, U10.A1 (VOUT), U11.8 (VDD)
/STATUS_LED: R32.1, U1.29 (PA8)
/STATUS_LED_A: D6.2 (A), R32.2
/SWCLK: J3.4 (SWCLK), U1.37 (PA14)
/SWDIO: J3.2 (SWDIO), U1.34 (PA13)
/SYS: C15.1, TP2.1, U3.1 (SYS), U4.1 (IN), U4.3 (EN)
/TS_COLD_REF: R38.2, R39.1, U12.3 (INA+)
/TS_HOT_REF: R40.2, R41.1, U12.6 (INB-)
/USB_DM: J1.A7 (D-), J1.B7 (D-), U1.32 (PA11), U2.3 (IO2), U2.4 (IO2)
/USB_DP: J1.A6 (D+), J1.B6 (D+), U1.33 (PA12), U2.1 (IO1), U2.6 (IO1)
/USB_ILIM_SET: R44.1, U13.C2 (SETI)
/USB_INPUT_ON: U13.A1 (ON), U14.6 (1Q_N)
/USB_LATCH_CLEAR_N: Q7.3 (D), R48.2, U14.1 (1CLR_N), U15.2 (RESET_N)
/USB_LATCH_CLOCK: Q6.3 (D), R47.2, U14.3 (1CLK)
/USB_RESUME_PULSE: Q7.1 (G), R50.1, U1.19 (PB1)
/USB_SUSPEND_PULSE: Q6.1 (G), R49.1, U1.12 (PA2)
/V3V3: C1.1, C2.1, C3.1, C4.1, C16.1, C22.1, C25.1, C29.1, J3.1 (VTref), R1.1, R2.1, R4.1, R11.1, R15.1, R37.1, R38.1, R40.1, TP3.1, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U4.5 (OUT), U8.2 (VDD), U10.A2 (VIN), U12.8 (VCC)
/VBUS: C31.1, C32.1, C33.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R13.1, R47.1, R48.1, U2.5 (VBUS), U13.B1 (IN), U14.2 (1D), U14.4 (1PRE_N), U14.10 (2PRE_N), U14.14 (VCC), U15.3 (VDD)
/VBUS_GATE: Q3.1 (G), R13.2, R14.1
/VBUS_LIMITED: C13.1, R12.1, U3.10 (IN), U13.B2 (OUT)
/VBUS_N: Q3.3 (D), R15.2, U1.10 (PA0)
/VCAP: C5.1, U1.22 (VCAP)
/VDDA: C6.1, C7.1, R1.2, U1.9 (VDDA)
unnamed: R4.2, SW1.1, U1.38 (PA15)

Notes on the sheet:
01 MCU / RTC / UI
02 USB-C / CHARGER
03 POWER / FUEL GAUGE
04 AUDIO / SD / INDICATORS
ENGINEERING DRAFT - NOT FOR FABRICATION - See hardware/xe-minimal/README.md
